# Keil uVision project 1.uvprojx, settings and files
target first (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group main
    ./: main.c init.c timer.c timer.h buttons.c buttons.h indicator.c indicator.h commytat.c commytat.h
  group include
    ./: eth_v3.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:TIMER 1.5
